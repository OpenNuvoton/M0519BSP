# Keil uVision project FreeRTOS_Demo.uvproj, settings and files
target FreeRTOS_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M0519VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FreeRTOS_Demo +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M0519\Include;..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM0;..\..\FreeRTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System
    ../../../Library/Device/Nuvoton/M0519/Source/ARM/: startup_M0519.s
    ../../../Library/Device/Nuvoton/M0519/Source/: system_M0519.c
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: QueueSet.c flash.c PollQ.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/SOURCE/: tasks.c timers.c list.c queue.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c
