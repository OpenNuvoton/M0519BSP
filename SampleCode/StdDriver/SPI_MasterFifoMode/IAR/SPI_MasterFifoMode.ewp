# IAR project SPI_MasterFifoMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0519AE series Nuvoton M0519AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M0519\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_MasterFifoMode.bin
  ILINK.IlinkOutputFile: SPI_MasterFifoMode.out
  ILINK.IlinkIcfFile: SPI_MasterFifoMode.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0519/Source/IAR/: startup_M0519.s
    ../../../../Library/Device/Nuvoton/M0519/Source/: system_M0519.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c spi.c uart.c
  group User
    ../: main.c
