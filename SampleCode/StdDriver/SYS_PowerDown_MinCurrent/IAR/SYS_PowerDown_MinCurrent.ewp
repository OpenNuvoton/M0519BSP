# IAR project SYS_PowerDown_MinCurrent.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0519AE series Nuvoton M0519AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M0519\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PowerDown_MinCurrent.bin
  ILINK.IlinkOutputFile: SYS_PowerDown_MinCurrent.out
  ILINK.IlinkIcfFile: SYS_PowerDown_MinCurrent.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0519/Source/IAR/: startup_M0519.s
    ../../../../Library/Device/Nuvoton/M0519/Source/: system_M0519.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
