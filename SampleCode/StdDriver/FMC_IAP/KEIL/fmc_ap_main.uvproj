# Keil uVision project fmc_ap_main.uvproj, settings and files
target APROM_code (6160000::V6.16::ARMCLANG)
  device: M0519VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: APROM_code
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M0519\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M0519.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0519/Source/ARM/: startup_M0519.s
    ../../../../Library/Device/Nuvoton/M0519/Source/: system_M0519.c
  group User
    ../: APROM_main.c
    ./: ap_image.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c fmc.c clk.c sys.c
