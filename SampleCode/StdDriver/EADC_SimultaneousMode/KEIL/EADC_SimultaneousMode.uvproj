# Keil uVision project EADC_SimultaneousMode.uvproj, settings and files
target EADC_SimultaneousMode (6160000::V6.16::ARMCLANG)
  device: M0519VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: EADC_SimultaneousMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M0519\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M0519.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0519/Source/: system_M0519.c
    ../../../../Library/Device/Nuvoton/M0519/Source/ARM/: startup_M0519.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c eadc.c
