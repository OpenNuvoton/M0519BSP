# Keil uVision project SPI_SDCard.uvproj, settings and files
target SPI_SDCard (ARM-ADS)
  device: M0519VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SPI_SDCard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M0519\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Component\inc;..\..\..\..\ThirdParty\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M0519.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0519/Source/: system_M0519.c
    ../../../../Library/Device/Nuvoton/M0519/Source/ARM/: startup_M0519.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: spi.c retarget.c uart.c clk.c gpio.c
  group SDCard
    ../../../../Library/Component/src/: SDCard.c
  group FATFS
    ../../../../ThirdParty/FATFS/: diskio.c ff.c
